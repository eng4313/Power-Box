# Keil uVision project Power_Box_V2.uvprojx, settings and files
target Power_Box_V2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Power_Box_V2 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BackLight;../BUS-SPI;../LCD;../SD-RAM;../W25Q32;../ZFM40;../TOUCH;../EEPROM;../Typedef;../ISD1730;../Storage;../BDC;../LOG;../Channel-Manager;../Channel-HW;../RTC;..\debug_link
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_ll_fmc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group LCD
    ../LCD/: lcd.c
  group BackLight
    ../BackLight/: backlight.c
  group BUS-SPI
    ../BUS-SPI/: spi_bus.c
  group W25Q32
    ../W25Q32/: w25q32.c
  group TOUCH
    ../TOUCH/: touch.c
  group ZFM40
    ../ZFM40/: zfm40.c
  group ISD1730
    ../ISD1730/: isd1730.c
  group EEPROM
    ../EEPROM/: AT24Cxx.c
  group Typedef
    ../Typedef/: typedef.h
  group Sorage
    ../Storage/: storage.c
  group BDC
    ../BDC/: bcd.c
  group LOG
    ../LOG/: log.c
  group Channel-Manager
    ../Channel-Manager/: channel_manager.c
  group SD-RAM
    ../SD-RAM/: sdram.c
  group Channel-HW
    ../Channel-HW/: channel_hw.c
  group RTC
    ../RTC/: rtc.c
  group debug_link
    ../debug_link/: debug_link.c
software components: CMSIS:CORE 4.3.0
